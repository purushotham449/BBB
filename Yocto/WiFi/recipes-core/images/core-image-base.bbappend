IMAGE_BOOT_FILES:append = " am335x-boneblack-wireless.dtb"